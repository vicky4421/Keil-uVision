# Keil uVision project FSM Linked Structure.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FSM_Linked_Structure
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c
  group fsm
    ./: fsm.h fsm.c state_idle.c state_running.c state_error.c
  group drivers
    ./: led.h led.c button.h button.c
  group systick
    ./: systick.h systick.c
  group state
    ./: state.h
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
